## base_external/configs/aesd_qemu_defconfig
```kconfig
BR2_PACKAGE_BUSYBOX_SHOW_OTHERS=y
BR2_PACKAGE_AESD_ASSIGNMENTS=y
BR2_PACKAGE_DROPBEAR=y
BR2_TARGET_GENERIC_ROOT_PASSWD="root"
```
